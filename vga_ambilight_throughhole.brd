File: vga_ambilight_throughhole.brd (EAGLE design)
At the start: 46.4 x 40.6 mm, 16 parts, among them IC1 QUAD_OPAMPD

Commit message: commit
Routing:
- net G: track 50.4 -> 53.3 mm
